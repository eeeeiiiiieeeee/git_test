# Keil uVision project GD32EPRTV_START.uvprojx, settings and files
target GD32EPRTV_START (6130001::V6.13.1::.\ARMCLANG)
  device: GD32EPRTVD GigaDevice
  pack: GigaDevice.GD32EPRT_DFP.1.1.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x060000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER GD32E50X GD32EPRT
  c include: ..\inc;..\..\..\Utilities;..\..\..\..\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include;..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include;..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbd_library\class\device\cdc\Include;..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbd_library\device\Include;..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbd_library\usbd\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Appliction
    ../src/: main.c gd32e50x_it.c gd32e50x_usbd_hw.c
  group CMSIS
    ../src/: system_gd32e50x.c
  group GD32E50x_Peripherals
    ../../../../GD32E50x_Firmware_Library/GD32E50x_standard_peripheral/Source/: gd32e50x_dma.c gd32e50x_fmc.c gd32e50x_gpio.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_timer.c gd32e50x_usart.c gd32e50x_exti.c
  group USBD_Drivers
    ../../../../GD32E50x_Firmware_Library/GD32E50x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
  group USBD_Device
    ../../../../GD32E50x_Firmware_Library/GD32E50x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Class
    ../../../../GD32E50x_Firmware_Library/GD32E50x_usbd_library/class/device/cdc/Source/: cdc_acm_core.c
  group Startup
    ../../../../GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32eprt.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
