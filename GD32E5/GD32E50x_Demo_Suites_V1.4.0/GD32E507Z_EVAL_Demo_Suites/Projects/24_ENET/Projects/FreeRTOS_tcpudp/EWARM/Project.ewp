# IAR project Project.ewp, settings and files
configuration GD32E507Z_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: GD32E507xE GD GD32E507xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E50X_CL; GD32E50X
  ICCARM.CCIncludePath2: ..\..\..\Third_party\lwip-2.1.2\src\include; ..\..\..\Third_party\lwip-2.1.2\port\GD32E50x\FreeRTOS; ..\..\..\Third_party\lwip-2.1.2\port\GD32E50x; ..\inc; ..\..\..\..\..\..\GD32E50x_Firmware_Library\CMSIS; ..\..\..\..\..\..\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include; ..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include; ..\..\..\..\..\Utilities; ..\..\..\Third_party\FreeRTOS-10.3.1\include; ..\..\..\Third_party\FreeRTOS-10.3.1\portable\IAR\ARM_CM33_NTZ\non_secure
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32e50x_enet_eval.c gd32e50x_it.c hello_gigadevice.c main.c netconf.c tcp_client.c udp_echo.c
  group CMSIS
    ../../../../../../GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/: system_gd32e50x.c
  group Doc
    ../: readme.txt
  group FreeRTOS
    ../../../Third_party/FreeRTOS-10.3.1/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../Third_party/FreeRTOS-10.3.1/portable/MemMang/: heap_4.c
    ../../../Third_party/FreeRTOS-10.3.1/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group GD32E50x_EVAL
    ../../../../../Utilities/: gd32e507z_eval.c
  group GD32E50x_Peripherals
    ../../../../../../GD32E50x_Firmware_Library/GD32E50x_standard_peripheral/Source/: gd32e50x_adc.c gd32e50x_bkp.c gd32e50x_can.c gd32e50x_cmp.c gd32e50x_crc.c gd32e50x_ctc.c gd32e50x_dac.c gd32e50x_dbg.c gd32e50x_dma.c gd32e50x_enet.c gd32e50x_exmc.c gd32e50x_exti.c gd32e50x_fmc.c gd32e50x_fwdgt.c gd32e50x_gpio.c gd32e50x_i2c.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_rtc.c gd32e50x_sdio.c gd32e50x_shrtimer.c gd32e50x_spi.c gd32e50x_sqpi.c gd32e50x_timer.c gd32e50x_tmu.c gd32e50x_usart.c gd32e50x_wwdgt.c
  group LwIP
    ../../../Third_party/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../Third_party/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Third_party/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../Third_party/lwip-2.1.2/src/netif/: ethernet.c
  group LwIP_Port
    ../../../Third_party/lwip-2.1.2/port/GD32E50x/FreeRTOS/: ethernetif.c sys_arch.c
  group Startup
    ../../../../../../GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/IAR/: startup_gd32e50x_cl.s
