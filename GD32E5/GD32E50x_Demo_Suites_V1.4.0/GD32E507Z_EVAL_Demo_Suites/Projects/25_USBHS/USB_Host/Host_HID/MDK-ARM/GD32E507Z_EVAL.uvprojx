# Keil uVision project GD32E507Z_EVAL.uvprojx, settings and files
target GD32E50X(USB_FS) (6130001::V6.13.1::.\ARMCLANG)
  device: GD32E507ZE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.4.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32E50X,GD32E50X_CL
  c include: ..\..\..\..\..\..\GD32E50x_Firmware_Library\CMSIS;..\..\..\..\..\..\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\driver\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\host\core\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\host\class\hid\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\ustd\common;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\ustd\class\hid;..\inc;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../src/: main.c usbh_usr.c gd32e50x_it.c gd32e50x_usb_hw.c usbh_usr_lcd.c lcd_font.c lcd_log.c
  group CMSIS
    ../src/: system_gd32e50x.c
  group GD32E50x_Peripherals
    ../../../../../../GD32E50x_Firmware_Library/GD32E50x_standard_peripheral/Source/: gd32e50x_exmc.c gd32e50x_exti.c gd32e50x_fmc.c gd32e50x_gpio.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_timer.c gd32e50x_usart.c
  group GD32E50x_EVAL
    ../../../../../Utilities/: gd32e507z_eval.c
    ../src/: gd32e50x_lcd_eval.c
  group USB_Driver
    ../../../../../../GD32E50x_Firmware_Library/GD32E50x_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../../GD32E50x_Firmware_Library/GD32E50x_usbhs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../../GD32E50x_Firmware_Library/GD32E50x_usbhs_library/host/class/hid/Source/: usbh_hid_core.c usbh_standard_hid.c
  group Startup
    ../../../../../../GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32e50x_cl.s
  group Doc
    ../: readme.txt
target GD32E50X(USB_HS) (6130001::V6.13.1::.\ARMCLANG)
  device: GD32E507ZE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.4.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_USB_HS,GD32E50X,GD32E50X_CL
  c include: ..\inc;..\..\..\..\..\..\GD32E50x_Firmware_Library\CMSIS;..\..\..\..\..\..\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\driver\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\host\core\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\host\class\hid\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\ustd\common;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\ustd\class\hid;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: CMSIS:CORE 5.2.0
