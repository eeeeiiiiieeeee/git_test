# Keil uVision project GD32E507Z_EVAL.uvprojx, settings and files
target GD32E50X(USB_FS) (6130001::V6.13.1::.\ARMCLANG)
  device: GD32E507ZE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.4.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: GD32E50X,GD32E50X_CL,USE_STDPERIPH_DRIVER,USE_USB_FS
  c include: ..\..\..\..\..\..\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\driver\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\device\core\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\device\class\hid\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\ustd\common;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\ustd\class\hid;..\..\..\..\..\..\GD32E50x_Firmware_Library\CMSIS;..\inc;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../src/: app.c gd32e50x_hw.c gd32e50x_it.c hid_keyboard_itf.c
  group CMSIS
    ../src/: system_gd32e50x.c
  group GD32E50x_Peripherals
    ../../../../../../GD32E50x_Firmware_Library/GD32E50x_standard_peripheral/Source/: gd32e50x_exti.c gd32e50x_gpio.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_timer.c gd32e50x_usart.c
  group GD32E50x_EVAL
    ../../../../../Utilities/: gd32e507z_eval.c
  group USB_Driver
    ../../../../../../GD32E50x_Firmware_Library/GD32E50x_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../../GD32E50x_Firmware_Library/GD32E50x_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../../GD32E50x_Firmware_Library/GD32E50x_usbhs_library/device/class/hid/Source/: standard_hid_core.c
  group Startup
    ../../../../../../GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32e50x_cl.s
  group Doc
    ../: readme.txt
target GD32E50X(USB_HS) (6130001::V6.13.1::.\ARMCLANG)
  device: GD32E507ZE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.4.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: GD32E50X,GD32E50X_CL,USE_STDPERIPH_DRIVER,USE_USB_HS
  c include: ..\inc;..\..\..\..\..\..\GD32E50x_Firmware_Library\CMSIS;..\..\..\..\..\..\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\driver\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\device\core\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\device\class\hid\Include;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\ustd\common;..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\ustd\class\hid;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: CMSIS:CORE 5.2.0
